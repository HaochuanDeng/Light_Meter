# Keil uVision project Light_Meter.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Light_Meter +hex
  c flags: Optimize=9
  c include: ..\CODE;.\LED;.\RCC;.\WDT;.\RST;.\EXTI;.\EEPROM;.\ADC;.\DELAY;.\TIMER;.\IIC;.\VEML7700;.\OLED;.\AE;.\STATE_MACHINE
  group USER
    ./: main.c
  group LED
    ./LED/: LED.c
  group RCC
    ./RCC/: RCC.c
  group WDT
    ./WDT/: WDT.c
  group RST
    ./RST/: RST.c
  group EXTI
    ./EXTI/: EXTI.c
  group EEPROM
    ./EEPROM/: EEPROM.c
  group ADC
    ./ADC/: ADC.c
  group DELAY
    ./DELAY/: DELAY.c
  group TIMER
    ./TIMER/: TIMER.c
  group IIC
    ./IIC/: IIC.c
  group VEML7700
    ./VEML7700/: VEML7700.c
  group OLED
    ./OLED/: OLED.c
  group AE
    ./AE/: AE.c
  group STATE_MACHINE
    ./STATE_MACHINE/: STATE_MACHINE.c
